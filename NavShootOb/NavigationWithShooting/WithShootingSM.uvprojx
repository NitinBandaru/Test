# Keil uVision project WithShootingSM.uvprojx, settings and files
target BaseFrameworkTarget (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: BaseTarget
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=3 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Main
    ./Source/: HSMTemplateMain.c
  group Source
    ./Source/: EventCheckers.c MapKeys.c RobotSM.c NavigationSM.c PWMModule.c PeriodicInterrupt.c InputCapture2.c InputCapture1.c ControlService.c StartService.c CommunicationSM.c SendingCommandSM.c SPIModule.c ShootingSM.c AlignInputCapture.c UltrasonicInputCapture.c LoadPWMModule.c ObstacleSM.c
  group Headers
    ./Headers/: uartstdio.h Bin_Const.h BITDEFS.H ES_CheckEvents.h ES_Configure.h ES_DeferRecall.h ES_Events.h ES_Framework.h ES_General.h ES_LookupTables.h ES_Port.h ES_PostList.h ES_PriorTables.h ES_Queue.h ES_ServiceHeaders.h ES_Timers.h ES_Types.h EventCheckers.h termio.h MapKeys.h InputCapture2.h InputCapture1.h PeriodicInterrupt.h PWMModule.h ControlService.h RobotSM.h NavigationSM.h StartService.h CommunicationSM.h SendingCommandSM.h SPIModule.h ShootingSM.h AlignInputCapture.h UltrasonicInputCapture.h LoadPWMModule.h ShootPWMModule.h ObstacleSM.h
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
  group Startup
    ./StartUp/: startup_rvmdk.S
  group Framework
    ./Source/: ES_CheckEvents.c ES_DeferRecall.c ES_Framework.c ES_LookupTables.c ES_Port.c ES_PostList.c ES_Queue.c ES_Timers.c retarget.c termio.c uartstdio.c
